# Keil uVision project LiteOSD.uvproj, settings and files
target Target 1 (MCS-51)
  device: EFM8BB21F16G-QFN20 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) IROM(0-0x3FFF) CLOCK(50000000)
  output: LiteOSD +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\src;.\inc
  group Source Group 1
    ./: SILABS_STARTUP.A51
    ./src/: main.c
  group scr
    ./src/: InitDevice.c Interrupts.c spi.c
