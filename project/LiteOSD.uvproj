# Keil uVision project LiteOSD.uvproj, settings and files
target LiteOSD (MCS-51)
  device: EFM8BB21F16G-QFN20 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) IROM(0-0x3FFF) CLOCK(50000000)
  output: LiteOSD
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\lib
  group startup
    ./: SILABS_STARTUP.A51
  group user
    ../src/: main.c show.c InitDevice.c interrupts.c
